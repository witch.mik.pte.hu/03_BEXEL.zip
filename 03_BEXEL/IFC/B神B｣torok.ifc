Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2021-05-09T13:24:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun May 09 13:24:40 2021 * Host: DESKTOP-UJ4848S * Database: C:\Users\ETI\AppData\Local\Temp\8e5625f3-41f0-48ee-9c98-3bbe6bc567f9\9301742a-da7d-474f-8921-749c2f34324d\ifc * Database version: 5507 * Database creation date: Sun May 09 13:24:35 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun May 09 13:24:35 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun May 09 13:24:35 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 5
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (5)
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_ProductRequirements - Category: Levels
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
00 Ground level | 00 Ground level | 0
01 Level | 01 Level | 4000
02 Level | 02 Level | 8000
03 Level | 03 Level | 12000
04 Roof | 04 Roof | 16000

# IfcBuildingElementProxy: 600x600mm (6)
Type - Material: kov chrom, bílá technika - sklo, bílá technika - plášť, bílá technika - sklokeramika, bílá technika - sokl
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: 600x600mm
Type - Materials and Finishes - plášt: bílá technika - plášť; plotny: kov chrom; sklo: bílá technika - sklo; sklokeramická deska: bílá technika - sklokeramika; sokl: bílá technika - sokl; úchytky: kov chrom
Type - Other - Category: Specialty Equipment; Family Name: cooker_60x60_16754
Type - Pset_BuildingElementProxyCommon - Reference: 600x600mm
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 600x600mm
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Moves With Nearby Elements: no; Host: Floor : Belső kerámia padló rétegrend
Dimensions - Area: 3.23109 m2; Volume: 0.0724895 m3
Identity Data - Comments: Bútor
Other - Family: cooker_60x60_16754: 600x600mm; Family and Type: cooker_60x60_16754: 600x600mm; Type: cooker_60x60_16754: 600x600mm; Type Id: cooker_60x60_16754: 600x600mm
Phasing - Phase Created: Phase 1
Name (cooker_60x60_16754:600x600mm:...) | In | Level
389021 | 01 Level | Level: 01 Level
389057 | 01 Level | Level: 01 Level
390291 | 02 Level | Level: 02 Level
390327 | 02 Level | Level: 02 Level
391561 | 03 Level | Level: 03 Level
391597 | 03 Level | Level: 03 Level

# IfcBuildingElementProxy: BOX (90)
Type - Material: 05_Ragasztott fa
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: BOX
Type - Other - Category: Generic Models; Family Name: BOX
Type - Pset_BuildingElementProxyCommon - Reference: BOX
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: BOX
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Moves With Nearby Elements: no
Identity Data - Comments: Bútor
Materials and Finishes - Mat: 05_Ragasztott fa
Other - Family: BOX: BOX; Family and Type: BOX: BOX; Type: BOX: BOX; Type Id: BOX: BOX
Phasing - Phase Created: Phase 1
Name (BOX:BOX:...) | In | Elevation from Level (mm) = Offset from Host (mm) | Host | Level | Area (m2) | Height (mm) | Length (mm) | Volume (m3) | Width (mm) | Element name
388962 | 01 Level | 0 | Level : 01 Level | Level: 01 Level | 3.39 | 900 | 600 | 1.026 | 1900 | counter
388963 | 01 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 01 Level | 2.34 | 900 | 1200 | 0.648 | 600 | counter
388964 | 01 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 01 Level | 4.29 | 900 | 600 | 1.35 | 2500 | counter
388971 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
388993 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 0.44 | 400 | 400 | 0.056 | 350
388994 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 0.44 | 400 | 400 | 0.056 | 350
388995 | 01 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 01 Level | 2.43 | 600 | 300 | 0.45 | 2500 | counter
388996 | 01 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 01 Level | 0.99 | 600 | 300 | 0.162 | 900 | counter
388997 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 0.44 | 400 | 400 | 0.056 | 350
388998 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
389002 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 2.475 | 750 | 1500 | 0.675 | 600
389003 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 2.92 | 1800 | 400 | 0.72 | 1000 | shelf
389005 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 0.89 | 400 | 1000 | 0.14 | 350
389030 | 01 Level | 0 | Level : 01 Level | Level: 01 Level | 1.92 | 600 | 1800 | 0.378 | 350
389031 | 01 Level | 0 | Level : 01 Level | Level: 01 Level | 3.36 | 1800 | 400 | 0.864 | 1200 | shelf
389034 | 01 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 01 Level | 3.39 | 900 | 600 | 1.026 | 1900 | counter
389035 | 01 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 01 Level | 2.34 | 900 | 1200 | 0.648 | 600 | counter
389036 | 01 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 01 Level | 4.29 | 900 | 600 | 1.35 | 2500 | counter
389043 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
389044 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 0.44 | 400 | 400 | 0.056 | 350
389045 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 0.44 | 400 | 400 | 0.056 | 350
389046 | 01 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 01 Level | 2.43 | 600 | 300 | 0.45 | 2500 | counter
389047 | 01 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 01 Level | 0.99 | 600 | 300 | 0.162 | 900 | counter
389048 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 0.44 | 400 | 400 | 0.056 | 350
389049 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
389053 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 2.475 | 750 | 1500 | 0.675 | 600
389054 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 2.92 | 1800 | 400 | 0.72 | 1000 | shelf
389056 | 01 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 01 Level | 0.89 | 400 | 1000 | 0.14 | 350
389066 | 01 Level | 0 | Level : 01 Level | Level: 01 Level | 1.92 | 600 | 1800 | 0.378 | 350
389067 | 01 Level | 0 | Level : 01 Level | Level: 01 Level | 3.36 | 1800 | 400 | 0.864 | 1200 | shelf
390232 | 02 Level | 0 | Level : 02 Level | Level: 02 Level | 3.39 | 900 | 600 | 1.026 | 1900 | counter
390233 | 02 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 02 Level | 2.34 | 900 | 1200 | 0.648 | 600 | counter
390234 | 02 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 02 Level | 4.29 | 900 | 600 | 1.35 | 2500 | counter
390241 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
390263 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 0.44 | 400 | 400 | 0.056 | 350
390264 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 0.44 | 400 | 400 | 0.056 | 350
390265 | 02 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 02 Level | 2.43 | 600 | 300 | 0.45 | 2500 | counter
390266 | 02 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 02 Level | 0.99 | 600 | 300 | 0.162 | 900 | counter
390267 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 0.44 | 400 | 400 | 0.056 | 350
390268 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
390272 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 2.475 | 750 | 1500 | 0.675 | 600
390273 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 2.92 | 1800 | 400 | 0.72 | 1000 | shelf
390275 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 0.89 | 400 | 1000 | 0.14 | 350
390300 | 02 Level | 0 | Level : 02 Level | Level: 02 Level | 1.92 | 600 | 1800 | 0.378 | 350
390301 | 02 Level | 0 | Level : 02 Level | Level: 02 Level | 3.36 | 1800 | 400 | 0.864 | 1200 | shelf
390304 | 02 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 02 Level | 3.39 | 900 | 600 | 1.026 | 1900 | counter
390305 | 02 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 02 Level | 2.34 | 900 | 1200 | 0.648 | 600 | counter
390306 | 02 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 02 Level | 4.29 | 900 | 600 | 1.35 | 2500 | counter
390313 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
390314 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 0.44 | 400 | 400 | 0.056 | 350
390315 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 0.44 | 400 | 400 | 0.056 | 350
390316 | 02 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 02 Level | 2.43 | 600 | 300 | 0.45 | 2500 | counter
390317 | 02 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 02 Level | 0.99 | 600 | 300 | 0.162 | 900 | counter
390318 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 0.44 | 400 | 400 | 0.056 | 350
390319 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
390323 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 2.475 | 750 | 1500 | 0.675 | 600
390324 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 2.92 | 1800 | 400 | 0.72 | 1000 | shelf
390326 | 02 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 02 Level | 0.89 | 400 | 1000 | 0.14 | 350
390336 | 02 Level | 0 | Level : 02 Level | Level: 02 Level | 1.92 | 600 | 1800 | 0.378 | 350
390337 | 02 Level | 0 | Level : 02 Level | Level: 02 Level | 3.36 | 1800 | 400 | 0.864 | 1200 | shelf
391502 | 03 Level | 0 | Level : 03 Level | Level: 03 Level | 3.39 | 900 | 600 | 1.026 | 1900 | counter
391503 | 03 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 03 Level | 2.34 | 900 | 1200 | 0.648 | 600 | counter
391504 | 03 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 03 Level | 4.29 | 900 | 600 | 1.35 | 2500 | counter
391511 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
391533 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 0.44 | 400 | 400 | 0.056 | 350
391534 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 0.44 | 400 | 400 | 0.056 | 350
391535 | 03 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 03 Level | 2.43 | 600 | 300 | 0.45 | 2500 | counter
391536 | 03 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 03 Level | 0.99 | 600 | 300 | 0.162 | 900 | counter
391537 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 0.44 | 400 | 400 | 0.056 | 350
391538 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
391542 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 2.475 | 750 | 1500 | 0.675 | 600
391543 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 2.92 | 1800 | 400 | 0.72 | 1000 | shelf
391545 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 0.89 | 400 | 1000 | 0.14 | 350
391570 | 03 Level | 0 | Level : 03 Level | Level: 03 Level | 1.92 | 600 | 1800 | 0.378 | 350
391571 | 03 Level | 0 | Level : 03 Level | Level: 03 Level | 3.36 | 1800 | 400 | 0.864 | 1200 | shelf
391574 | 03 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 03 Level | 3.39 | 900 | 600 | 1.026 | 1900 | counter
391575 | 03 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 03 Level | 2.34 | 900 | 1200 | 0.648 | 600 | counter
391576 | 03 Level | 0 | Floor : Belső kerámia padló rétegrend | Level: 03 Level | 4.29 | 900 | 600 | 1.35 | 2500 | counter
391583 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
391584 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 0.44 | 400 | 400 | 0.056 | 350
391585 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 0.44 | 400 | 400 | 0.056 | 350
391586 | 03 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 03 Level | 2.43 | 600 | 300 | 0.45 | 2500 | counter
391587 | 03 Level | 1500 | Floor : Belső kerámia padló rétegrend | Level: 03 Level | 0.99 | 600 | 300 | 0.162 | 900 | counter
391588 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 0.44 | 400 | 400 | 0.056 | 350
391589 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 6.22 | 1800 | 400 | 1.8 | 2500 | shelf
391593 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 2.475 | 750 | 1500 | 0.675 | 600
391594 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 2.92 | 1800 | 400 | 0.72 | 1000 | shelf
391596 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 0.89 | 400 | 1000 | 0.14 | 350
391606 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 1.92 | 600 | 1800 | 0.378 | 350
391607 | 03 Level | 0 | Floor : Belső parketta padló rétegrend | Level: 03 Level | 3.36 | 1800 | 400 | 0.864 | 1200 | shelf

# IfcBuildingElementProxy: BOX (6)
Type - Material: Aluminium
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: BOX
Type - Other - Category: Generic Models; Family Name: BOX
Type - Pset_BuildingElementProxyCommon - Reference: BOX
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: BOX
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm; Host: Floor : Belső kerámia padló rétegrend
Dimensions - Area: 2.52 m2; Height: 1800 mm; Length: 600 mm; Volume: 0.648 m3; Width: 600 mm
Identity Data - Comments: Bútor
Materials and Finishes - Mat: Aluminium
Other - Family: BOX: BOX; Family and Type: BOX: BOX; Type: BOX: BOX; Type Id: BOX: BOX
Phasing - Phase Created: Phase 1
Text - Element name: refrigerator
Name (BOX:BOX:...) | In | Level
388966 | 01 Level | Level: 01 Level
389038 | 01 Level | Level: 01 Level
390236 | 02 Level | Level: 02 Level
390308 | 02 Level | Level: 02 Level
391506 | 03 Level | Level: 03 Level
391578 | 03 Level | Level: 03 Level

# IfcBuildingElementProxy: BOX (6)
Type - Material: Aluminum
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: BOX
Type - Other - Category: Generic Models; Family Name: BOX
Type - Pset_BuildingElementProxyCommon - Reference: BOX
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: BOX
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 1.32 m2; Height: 800 mm; Length: 600 mm; Volume: 0.288 m3; Width: 600 mm
Identity Data - Comments: Bútor
Materials and Finishes - Mat: Aluminum
Other - Family: BOX: BOX; Family and Type: BOX: BOX; Type: BOX: BOX; Type Id: BOX: BOX
Phasing - Phase Created: Phase 1
Text - Element name: washing machine
Name (BOX:BOX:...) | In | Level | Host
388968 | 01 Level | Level: 01 Level | Level : 01 Level
389040 | 01 Level | Level: 01 Level | Level : 01 Level
390238 | 02 Level | Level: 02 Level | Level : 02 Level
390310 | 02 Level | Level: 02 Level | Level : 02 Level
391508 | 03 Level | Level: 03 Level | Level : 03 Level
391580 | 03 Level | Level: 03 Level | Floor : Belső kerámia padló rétegrend

# IfcFurnishingElement: 0762 x 1525mm (6)
Type - Material: Steel, Chrome Plated, Glass - Clear, Grey
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 560 mm; Length: 1525 mm; Width: 762 mm
Type - Identity Data - OmniClass Number: 23.40.20.14.17.11; OmniClass Title: Dining Room Tables; Type Name: 0762 x 1525mm
Type - Materials and Finishes - Base Material: Steel, Chrome Plated; Top Material: Glass - Clear, Grey
Type - Other - Category: Furniture; Family Name: M_Table-Dining
Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 0762 x 1525mm
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no
Dimensions - Area: 1.71334 m2; Volume: 0.0233059 m3
Identity Data - Comments: Bútor
Other - Family: M_Table-Dining: 0762 x 1525mm; Family and Type: M_Table-Dining: 0762 x 1525mm; Type: M_Table-Dining: 0762 x 1525mm; Type Id: M_Table-Dining: 0762 x 1525mm
Phasing - Phase Created: Phase 1
Name (M_Table-Dining:0762 x 1525mm:...) | In | Level | Host
389023 | 01 Level | Level: 01 Level | Level : 01 Level
389059 | 01 Level | Level: 01 Level | Level : 01 Level
390293 | 02 Level | Level: 02 Level | Level : 02 Level
390329 | 02 Level | Level: 02 Level | Level : 02 Level
391563 | 03 Level | Level: 03 Level | Level : 03 Level
391599 | 03 Level | Level: 03 Level | Floor : Belső parketta padló rétegrend

# IfcFurnishingElement: 1270mm (6)
Type - Material: TV - Black, TV - Glass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - CosAng: 0.871556 mm; Diagonal: 1270 mm; H: 622.675 mm; L: 1106.88 mm; SinAng: 0.490295 mm; Thickness: 110 mm
Type - Identity Data - Type Name: 1270mm
Type - Other - Category: Furniture; Family Name: M_TV - Flat Screen
Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1270mm
Constraints - Moves With Nearby Elements: no; Elevation from Level: 800 mm; Offset from Host: 800 mm
Dimensions - Area: 2.19736 m2; Volume: 0.10703 m3
Graphics - Stand: yes
Identity Data - Comments: Bútor
Other - Family: M_TV - Flat Screen: 1270mm; Family and Type: M_TV - Flat Screen: 1270mm; Type: M_TV - Flat Screen: 1270mm; Type Id: M_TV - Flat Screen: 1270mm
Phasing - Phase Created: Phase 1
Name (M_TV - Flat Screen:1270mm:...) | In | Level | Host
389024 | 01 Level | Level: 01 Level | Level : 01 Level
389060 | 01 Level | Level: 01 Level | Level : 01 Level
390294 | 02 Level | Level: 02 Level | Level : 02 Level
390330 | 02 Level | Level: 02 Level | Level : 02 Level
391564 | 03 Level | Level: 03 Level | Level : 03 Level
391600 | 03 Level | Level: 03 Level | Floor : Belső parketta padló rétegrend

# IfcFurnishingElement: 1346 x 1880mm - Double (6)
Type - Material: Linen, White, Birch
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 1880 mm; Width: 1346 mm
Type - Identity Data - OmniClass Number: 23.40.20.17.14.11; OmniClass Title: Beds; Type Name: 1346 x 1880mm - Double
Type - Materials and Finishes - Frame Material: Birch; Mattress Material: Linen, White
Type - Other - Category: Furniture; Family Name: M_Bed-Box
Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1346 x 1880mm - Double
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Host: Floor : Belső parketta padló rétegrend
Dimensions - Area: 5.47559 m2; Volume: 0.55611 m3
Identity Data - Comments: Bútor
Other - Family: M_Bed-Box: 1346 x 1880mm - Double; Family and Type: M_Bed-Box: 1346 x 1880mm - Double; Type: M_Bed-Box: 1346 x 1880mm - Double; Type Id: M_Bed-Box: 1346 x 1880mm - Double
Phasing - Phase Created: Phase 1
Name (M_Bed-Box:1346 x 1880mm - Double:...) | In | Level
388969 | 01 Level | Level: 01 Level
389041 | 01 Level | Level: 01 Level
390239 | 02 Level | Level: 02 Level
390311 | 02 Level | Level: 02 Level
391509 | 03 Level | Level: 03 Level
391581 | 03 Level | Level: 03 Level

# IfcFurnishingElement: 1830 x 0610mm (6)
Type - Material: Steel, Chrome Plated, Laminate, Ivory, Matte, Cherry
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 610 mm; Height: 734 mm; Width: 1830 mm
Type - Identity Data - OmniClass Number: 23.40.20.24.17; OmniClass Title: Sideboards; Type Name: 1830 x 0610mm
Type - Materials and Finishes - Desk-Body: Laminate, Ivory, Matte; Handle/Leg Material: Steel, Chrome Plated; Top Material: Cherry
Type - Other - Category: Furniture; Family Name: M_Credenza
Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 1830 x 0610mm
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no
Dimensions - Area: 5.67443 m2; Volume: 0.396594 m3
Identity Data - Comments: Bútor
Other - Family: M_Credenza: 1830 x 0610mm; Family and Type: M_Credenza: 1830 x 0610mm; Type: M_Credenza: 1830 x 0610mm; Type Id: M_Credenza: 1830 x 0610mm
Phasing - Phase Created: Phase 1
Name (M_Credenza:1830 x 0610mm:...) | In | Level | Host
389022 | 01 Level | Level: 01 Level | Level : 01 Level
389058 | 01 Level | Level: 01 Level | Level : 01 Level
390292 | 02 Level | Level: 02 Level | Level : 02 Level
390328 | 02 Level | Level: 02 Level | Level : 02 Level
391562 | 03 Level | Level: 03 Level | Level : 03 Level
391598 | 03 Level | Level: 03 Level | Floor : Belső parketta padló rétegrend

# IfcFurnishingElement: 900 x 2000 mm - single (6)
Type - Material: Birch, Linen, White
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 2000 mm; Width: 900 mm
Type - Identity Data - OmniClass Number: 23.40.20.17.14.11; OmniClass Title: Beds; Type Name: 900 x 2000 mm - single
Type - Materials and Finishes - Frame Material: Birch; Mattress Material: Linen, White
Type - Other - Category: Furniture; Family Name: M_Bed-Shaker
Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: 900 x 2000 mm - single
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Host: Floor : Belső parketta padló rétegrend
Dimensions - Area: 4.45578 m2; Volume: 0.480501 m3
Identity Data - Comments: Bútor
Other - Family: M_Bed-Shaker: 900 x 2000 mm - single; Family and Type: M_Bed-Shaker: 900 x 2000 mm - single; Type: M_Bed-Shaker: 900 x 2000 mm - single; Type Id: M_Bed-Shaker: 900 x 2000 mm - single
Phasing - Phase Created: Phase 1
Name (M_Bed-Shaker:900 x 2000 mm - single:...) | In | Level
388970 | 01 Level | Level: 01 Level
389042 | 01 Level | Level: 01 Level
390240 | 02 Level | Level: 02 Level
390312 | 02 Level | Level: 02 Level
391510 | 03 Level | Level: 03 Level
391582 | 03 Level | Level: 03 Level

# IfcFurnishingElement: M_Chair-Breuer (24)
Type - Material: Textile - Bamboo Weave, Steel, Chrome Plated
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: M_Chair-Breuer
Type - Materials and Finishes - Seat/Back Material: Textile - Bamboo Weave; Tubing Material: Steel, Chrome Plated
Type - Other - Category: Furniture; Family Name: M_Chair-Breuer
Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: M_Chair-Breuer
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no
Dimensions - Area: 0.490262 m2; Volume: 0.0128258 m3
Identity Data - Comments: Bútor
Other - Family: M_Chair-Breuer: M_Chair-Breuer; Family and Type: M_Chair-Breuer: M_Chair-Breuer; Type: M_Chair-Breuer: M_Chair-Breuer; Type Id: M_Chair-Breuer: M_Chair-Breuer
Phasing - Phase Created: Phase 1
Name (M_Chair-Breuer:M_Chair-Breuer:...) | In | Level | Host
389026 | 01 Level | Level: 01 Level | Level : 01 Level
389027 | 01 Level | Level: 01 Level | Level : 01 Level
389028 | 01 Level | Level: 01 Level | Level : 01 Level
389029 | 01 Level | Level: 01 Level | Level : 01 Level
389062 | 01 Level | Level: 01 Level | Level : 01 Level
389063 | 01 Level | Level: 01 Level | Level : 01 Level
389064 | 01 Level | Level: 01 Level | Level : 01 Level
389065 | 01 Level | Level: 01 Level | Level : 01 Level
390296 | 02 Level | Level: 02 Level | Level : 02 Level
390297 | 02 Level | Level: 02 Level | Level : 02 Level
390298 | 02 Level | Level: 02 Level | Level : 02 Level
390299 | 02 Level | Level: 02 Level | Level : 02 Level
390332 | 02 Level | Level: 02 Level | Level : 02 Level
390333 | 02 Level | Level: 02 Level | Level : 02 Level
390334 | 02 Level | Level: 02 Level | Level : 02 Level
390335 | 02 Level | Level: 02 Level | Level : 02 Level
391566 | 03 Level | Level: 03 Level | Level : 03 Level
391567 | 03 Level | Level: 03 Level | Level : 03 Level
391568 | 03 Level | Level: 03 Level | Level : 03 Level
391569 | 03 Level | Level: 03 Level | Level : 03 Level
391602 | 03 Level | Level: 03 Level | Floor : Belső parketta padló rétegrend
391603 | 03 Level | Level: 03 Level | Floor : Belső parketta padló rétegrend
391604 | 03 Level | Level: 03 Level | Floor : Belső parketta padló rétegrend
391605 | 03 Level | Level: 03 Level | Floor : Belső parketta padló rétegrend

# IfcFurnishingElement: M_Chair-Executive (6)
Type - Material: Plastic, Opaque Black, Textile - Slate Blue
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: M_Chair-Executive
Type - Materials and Finishes - Base/Armd Material: Plastic, Opaque Black; Caster Material: Plastic, Opaque Black; Seat/Back Material: Textile - Slate Blue
Type - Other - Category: Furniture; Family Name: M_Chair-Executive
Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: M_Chair-Executive
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Host: Floor : Belső parketta padló rétegrend
Dimensions - Area: 0.971983 m2; Volume: 0.0336862 m3
Identity Data - Comments: Bútor
Other - Family: M_Chair-Executive: M_Chair-Executive; Family and Type: M_Chair-Executive: M_Chair-Executive; Type: M_Chair-Executive: M_Chair-Executive; Type Id: M_Chair-Executive: M_Chair-Executive
Phasing - Phase Created: Phase 1
Name (M_Chair-Executive:M_Chair-Executive:...) | In | Level
389004 | 01 Level | Level: 01 Level
389055 | 01 Level | Level: 01 Level
390274 | 02 Level | Level: 02 Level
390325 | 02 Level | Level: 02 Level
391544 | 03 Level | Level: 03 Level
391595 | 03 Level | Level: 03 Level

# IfcFurnishingElement: Sofa (6)
Type - Material: Leather - Black, Metal - Chrome
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 725 mm; Height: 625 mm; Width: 1675 mm
Type - Identity Data - OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; Type Name: Sofa
Type - Materials and Finishes - Cushion Material: Leather - Black; Frame Material: Metal - Chrome
Type - Other - Category: Furniture; Family Name: M_Sofa-Corbu
Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Sofa
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no
Dimensions - Area: 4.95826 m2; Volume: 0.419586 m3
Identity Data - Comments: Bútor
Other - Family: M_Sofa-Corbu: Sofa; Family and Type: M_Sofa-Corbu: Sofa; Type: M_Sofa-Corbu: Sofa; Type Id: M_Sofa-Corbu: Sofa
Phasing - Phase Created: Phase 1
Name (M_Sofa-Corbu:Sofa:...) | In | Level | Host
389025 | 01 Level | Level: 01 Level | Level : 01 Level
389061 | 01 Level | Level: 01 Level | Level : 01 Level
390295 | 02 Level | Level: 02 Level | Level : 02 Level
390331 | 02 Level | Level: 02 Level | Level : 02 Level
391565 | 03 Level | Level: 03 Level | Level : 03 Level
391601 | 03 Level | Level: 03 Level | Floor : Belső parketta padló rétegrend

# IfcRailing: Railing:Stair 900 (5)
Material: Metal - Stainless Steel,Polished, 02_Metal Stud Layer, 05_Fa
Top Rail(Type) - Height: 900 mm; Type: Top Rail Type: Stair handrail; Use Top Rail: yes
Other(Type) - Category: Railings; Family Name: Railing
Identity Data(Type) - Type Name: Stair 900
Construction(Type) - Angled Joins: Add Vertical/Horizontal Segments; Baluster Offset: 0 mm; Landing Height Adjustment: 0 mm; Rail Connections: Trim; Railing Height: 900 mm; Tangent Joins: Extend Rails to Meet; Use Landing Height Adjustment: no
Pset_ProductRequirements - Category: Railings
Pset_QuantityTakeOff - Reference: Stair 900
Pset_RailingCommon - Reference: Stair 900; Height: 900 mm; IsExternal: no
BaseQuantities - sets with these values: 2
Constraints - Base Offset: 0 mm
Other - Category: Railings; Family: Railing: Stair 900; Family and Type: Railing: Stair 900; Type: Railing: Stair 900; Type Id: Railing: Stair 900
Phasing - Phase Created: Phase 1
Name (Railing:Stair 900:...) | In | Length (mm) | Offset from Path (mm)
388639 | 01 Level | 7569.69 | 25.4
389909 | 02 Level | 7569.69 | 25.4
391179 | 03 Level | 7569.69 | 25.4
392871 | 00 Ground level | 7569.69 | 25.4
405314 | 04 Roof | 2000 | 0
